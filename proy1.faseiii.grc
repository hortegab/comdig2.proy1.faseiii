<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.11'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>run</key><value>run_stop</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>Ar</value></param>
<param><key>value</key><value>0.</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>B</value></param>
<param><key>value</key><value>220e3</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>BW</value></param>
<param><key>value</key><value>B/2</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>BWaudio</value></param>
<param><key>value</key><value>5.5e3</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>D</value></param>
<param><key>value</key><value>Kf*V_pmi/BWaudio</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>DF</value></param>
<param><key>value</key><value>BW-BWaudio</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>Kf</value></param>
<param><key>value</key><value>DF/V_pmi</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>V_pmi</value></param>
<param><key>value</key><value>1.</value></param>
</block>
<block>
<key>variable_qtgui_check_box</key>
<param><key>id</key><value>run_stop</value></param>
<param><key>value</key><value>True</value></param>
<param><key>false</key><value>False</value></param>
<param><key>gui_hint</key><value>0,0,1,1</value></param>
<param><key>label</key><value>Inicial/Parar</value></param>
<param><key>true</key><value>True</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>int(e_usrp_samp.usrp2920(B))</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate_audio</value></param>
<param><key>value</key><value>int(BWaudio*2)</value></param>
</block>
<block>
<key>analog_const_source_x</key>
<param><key>id</key><value>analog_const_source_x_0</value></param>
<param><key>const</key><value>0.7</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>analog_sig_source_x</key>
<param><key>id</key><value>analog_sig_source_x_0</value></param>
<param><key>amp</key><value>1</value></param>
<param><key>freq</key><value>1000</value></param>
<param><key>offset</key><value>0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>samp_rate</key><value>samp_rate_audio</value></param>
<param><key>waveform</key><value>analog.GR_COS_WAVE</value></param>
</block>
<block>
<key>b_PSD_c</key>
<param><key>id</key><value>b_PSD_c_0</value></param>
<param><key>Ensayos</key><value>1000000</value></param>
<param><key>Fc</key><value>0</value></param>
<param><key>N</key><value>1024</value></param>
<param><key>Titulo</key><value>"PSD"</value></param>
<param><key>Ymax</key><value>6e-6</value></param>
<param><key>samp_rate_audio</key><value>samp_rate</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0_0_0_1_0_0</value></param>
<param><key>const</key><value>2*math.pi*Kf/samp_rate</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>epy_block</key>
<param><key>id</key><value>e_Accum_ff</value></param>
<param><key>_source_code</key><value>"""
Embedded Python Blocks:

Each time this file is saved, GRC will instantiate the first class it finds
to get ports and parameters of your block. The arguments to __init__  will
be the parameters. All of them are required to have default values!
"""

import numpy as np
from gnuradio import gr


class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
    """Hecho por Homoero Ortega. Es un acumulador puro, va acumulando cada muestra entrante mientras entrega lo que lleva acumulado hasta el momento. Puede convertirse en un integrador si la salida se divide en la frecuencia de muestreo de la senal"""

    def __init__(self):  # only default arguments here
        gr.sync_block.__init__(
            self,
            name='e_Accum_ff',   # will show up in GRC
            in_sig=[np.float32],
            out_sig=[np.float32]
        )
	self.memory=0.
    def work(self, input_items, output_items):
        """El acumulador"""
	in0=input_items[0]
	out0=output_items[0]
        L=len(in0)
	out0[:]=(self.memory+np.cumsum(in0))
	self.memory=out0[L-1]
        return len(out0)
</value></param>
</block>
<block>
<key>epy_module</key>
<param><key>id</key><value>e_usrp_samp</value></param>
<param><key>source_code</key><value>import math

# calculo de la frecuencia de muestreo para el USRP2920
# Hay un error introducido a propósito para que sea corregido por los estudiantes

def usrp2920(B):
	Kdmax=512
	samp_rate_usrp_rx=100e6
	Kdd=int(samp_rate_usrp_rx/B)
	Kda=pow(2,int(math.log(Kdd,10)))
	Kd=min(Kda,Kdmax)
	return samp_rate_usrp_rx/Kd
	
</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>import</key><value>import math</value></param>
</block>
<block>
<key>qtgui_const_sink_x</key>
<param><key>id</key><value>qtgui_const_sink_x_0</value></param>
<param><key>size</key><value>1024</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>color2</key><value>"red"</value></param>
<param><key>label2</key><value></value></param>
<param><key>size</key><value>1024</value></param>
<param><key>srate</key><value>samp_rate</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>rational_resampler_xxx</key>
<param><key>id</key><value>rational_resampler_xxx_0</value></param>
<param><key>decim</key><value>int(samp_rate_audio)</value></param>
<param><key>interp</key><value>int(samp_rate)</value></param>
<param><key>taps</key><value></value></param>
<param><key>type</key><value>fff</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>vs</value></param>
<param><key>stream_id</key><value>T1</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>vs_0</value></param>
<param><key>stream_id</key><value>T3</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>vso</value></param>
<param><key>stream_id</key><value>T1</value></param>
</block>
<connection><source_block_id>analog_sig_source_x_0</source_block_id><sink_block_id>rational_resampler_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_sig_source_x_0</source_block_id><sink_block_id>vs_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>e_Accum_ff</source_block_id><sink_block_id>blocks_multiply_const_vxx_0_0_0_1_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rational_resampler_xxx_0</source_block_id><sink_block_id>e_Accum_ff</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>vso</source_block_id><sink_block_id>b_PSD_c_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>vso</source_block_id><sink_block_id>qtgui_const_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>vso</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
